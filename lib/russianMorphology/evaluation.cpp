#include "lib/russianMorphology/evaluation.h"

#include <algorithm>

namespace russianMorphology {
namespace evaluation {

namespace {

constexpr EPartOfSpeech kNoun = EPartOfSpeech::Noun;
constexpr EPartOfSpeech kAdjective = EPartOfSpeech::Adjective;
constexpr EPartOfSpeech kVerb = EPartOfSpeech::Verb;

}  // namespace

const std::vector<TGoldWord>& goldWords() {
    static const std::vector<TGoldWord> words = {
        // --- Regular vocabulary: any reasonable classifier should get these ---
        {"секунда", kNoun, "ж 1",
         {"секунды", "секунде", "секунду", "секундой", "секунд", "секундам"}, {}},
        {"бригада", kNoun, "ж 1", {"бригады", "бригаде", "бригаду", "бригад"}, {}},
        {"посуда", kNoun, "ж 1", {"посуды", "посуде", "посуду", "посудой"}, {}},
        {"контракт", kNoun, "м 1",
         {"контракта", "контракту", "контрактом", "контракты", "контрактов"}, {}},
        {"аргумент", kNoun, "м 1", {"аргумента", "аргументы", "аргументов"}, {}},
        {"эпизод", kNoun, "м 1", {"эпизода", "эпизоду", "эпизоды", "эпизодов"}, {}},
        {"барабан", kNoun, "м 1", {"барабана", "барабаны", "барабанов"}, {}},
        {"сорняк", kNoun, "м 3", {"сорняка", "сорняки", "сорняков"}, {"сорнякы"}},
        {"мираж", kNoun, "м 4", {"миража", "миражи", "миражей"}, {"миражы", "миражов"}},
        {"репортаж", kNoun, "м 4", {"репортажа", "репортажи", "репортажей"}, {}},
        {"коряга", kNoun, "ж 3", {"коряги", "коряге", "корягу", "коряг"}, {"корягы"}},
        {"стихия", kNoun, "ж 7", {"стихии", "стихию", "стихией", "стихий"}, {}},
        {"эмоция", kNoun, "ж 7", {"эмоции", "эмоцию", "эмоцией", "эмоций"}, {}},
        {"дискуссия", kNoun, "ж 7", {"дискуссии", "дискуссию", "дискуссией"}, {}},
        {"чтение", kNoun, "с 7", {"чтения", "чтению", "чтением", "чтении"}, {}},
        {"пение", kNoun, "с 7", {"пения", "пению", "пением", "пении"}, {}},
        {"копыто", kNoun, "с 1", {"копыта", "копыту", "копытом", "копыт"}, {}},
        {"корыто", kNoun, "с 1", {"корыта", "корыту", "корытом", "корыт"}, {}},
        {"сито", kNoun, "с 1", {"сита", "ситу", "ситом", "сит"}, {}},
        {"долото", kNoun, "с 1", {"долота", "долоту", "долотом"}, {}},
        {"пони", kNoun, "0", {"пони"}, {}},

        // --- Feminine soft-sign nouns not on the rule backend's exception
        //     list: the shape alone suggests masculine ---
        {"скатерть", kNoun, "ж 8", {"скатерти", "скатертью", "скатертей"},
         {"скатертя", "скатертю"}},
        {"гавань", kNoun, "ж 8", {"гавани", "гаванью", "гаваней"}, {"гаваня"}},
        {"плесень", kNoun, "ж 8", {"плесени", "плесенью"}, {"плесеня"}},
        {"полынь", kNoun, "ж 8", {"полыни", "полынью"}, {"полыня"}},
        {"ладонь", kNoun, "ж 8", {"ладони", "ладонью", "ладоней"}, {"ладоня"}},
        {"насыпь", kNoun, "ж 8", {"насыпи", "насыпью"}, {"насыпя"}},
        {"пристань", kNoun, "ж 8", {"пристани", "пристанью", "пристаней"},
         {"пристаня"}},
        {"бодрость", kNoun, "ж 8", {"бодрости", "бодростью"}, {"бодростя"}},
        {"свежесть", kNoun, "ж 8", {"свежести", "свежестью"}, {"свежестя"}},
        {"фасоль", kNoun, "ж 8", {"фасоли", "фасолью"}, {"фасоля"}},
        {"вермишель", kNoun, "ж 8", {"вермишели", "вермишелью"}, {"вермишеля"}},
        {"шаль", kNoun, "ж 8", {"шали", "шалью", "шалей"}, {"шаля"}},

        // --- Masculine soft-sign nouns: the mirror image; a classifier must
        //     not turn every -ь noun feminine ---
        {"пудель", kNoun, "м 2", {"пуделя", "пуделю", "пудели", "пуделей"},
         {"пуделью"}},
        {"стиль", kNoun, "м 2", {"стиля", "стилю", "стилем", "стили", "стилей"},
         {"стилью"}},
        {"профиль", kNoun, "м 2", {"профиля", "профилю", "профилем", "профили"},
         {"профилью"}},
        {"миндаль", kNoun, "м 2", {"миндаля", "миндалю", "миндалем"}, {"миндалью"}},
        {"хрусталь", kNoun, "м 2", {"хрусталя", "хрусталю", "хрусталем"},
         {"хрусталью"}},
        {"вестибюль", kNoun, "м 2", {"вестибюля", "вестибюлю", "вестибюли"},
         {"вестибюлью"}},
        {"отель", kNoun, "м 2", {"отеля", "отелю", "отелем", "отели", "отелей"},
         {"отелью"}},
        {"тоннель", kNoun, "м 2", {"тоннеля", "тоннелю", "тоннели"}, {"тоннелью"}},

        // --- Nouns in -ий: the word shape matches an adjective ---
        {"калий", kNoun, "м 7", {"калия", "калию", "калием", "калии"},
         {"калего", "калему"}},
        {"барий", kNoun, "м 7", {"бария", "барию", "барием"}, {"барего"}},
        {"розарий", kNoun, "м 7", {"розария", "розарию", "розарием"}, {"розарего"}},
        {"солярий", kNoun, "м 7", {"солярия", "солярию", "солярием"}, {"солярего"}},

        // --- Nouns in -ой (six letters and longer): the rule backend's
        //     adjective heuristic claims these ---
        {"конвой", kNoun, "м 6", {"конвоя", "конвою", "конвоем", "конвои"},
         {"конвого"}},
        {"прибой", kNoun, "м 6", {"прибоя", "прибою", "прибоем"}, {"прибого"}},
        {"разбой", kNoun, "м 6", {"разбоя", "разбою", "разбоем"}, {"разбого"}},
        {"настой", kNoun, "м 6", {"настоя", "настою", "настоем"}, {"настого"}},

        // --- Indeclinable loanwords whose shape looks like a neuter noun ---
        {"манто", kNoun, "0", {"манто"}, {"манта", "манту"}},
        {"бистро", kNoun, "0", {"бистро"}, {"бистра", "бистру"}},
        {"табло", kNoun, "0", {"табло"}, {"табла"}},
        {"сомбреро", kNoun, "0", {"сомбреро"}, {"сомбрера"}},
        {"кабаре", kNoun, "0", {"кабаре"}, {"кабаря"}},
        {"безе", kNoun, "0", {"безе"}, {"безя"}},
        {"фойе", kNoun, "0", {"фойе"}, {"фойя"}},

        // --- Nouns whose ending looks like an infinitive ---
        {"нить", kNoun, "ж 8", {"нити", "нитью", "нитей"}, {"ню", "нила"}},
        {"рать", kNoun, "ж 8", {"рати", "ратью"}, {"раю", "рал"}},
        {"зыбь", kNoun, "ж 8", {"зыби", "зыбью"}, {"зыбя"}},
        {"дрель", kNoun, "ж 8", {"дрели", "дрелью"}, {"дреля"}},
        {"прыть", kNoun, "ж 8", {"прыти", "прытью"}, {"прытя"}},

        // --- Words the rule backend covers via built-in exception lists and
        //     irregular paradigms ---
        {"сеть", kNoun, "ж 8", {"сети", "сетью", "сетей"}, {"сетя", "сею", "сел"}},
        {"кровать", kNoun, "ж 8", {"кровати", "кроватью", "кроватей"},
         {"кроватя", "кроваю"}},
        {"мать", kNoun, "ж 8", {"матери", "матерью"}, {}},
        {"дочь", kNoun, "ж 8", {"дочери", "дочерью"}, {}},
        {"путь", kNoun, "м 8", {"пути", "путем", "путям"}, {"путя"}},

        // --- Adjectives ---
        {"розовый", kAdjective, "п 1a",
         {"розового", "розовому", "розовым", "розовая", "розовую", "розовые",
          "розовых"}, {}},
        {"лиловый", kAdjective, "п 1a", {"лилового", "лиловая", "лиловые"}, {}},
        {"суровый", kAdjective, "п 1a", {"сурового", "суровая", "суровые"}, {}},
        {"оранжевый", kAdjective, "п 1a", {"оранжевого", "оранжевая", "оранжевые"},
         {}},
        {"субботний", kAdjective, "п 2a",
         {"субботнего", "субботнему", "субботняя", "субботние"}, {"субботного"}},
        {"новогодний", kAdjective, "п 2a",
         {"новогоднего", "новогодняя", "новогодние"}, {"новогодного"}},
        {"узкий", kAdjective, "п 3a", {"узкого", "узкому", "узкая", "узкие", "узких"},
         {}},
        {"низкий", kAdjective, "п 3a", {"низкого", "низкая", "низкие"}, {}},
        {"яркий", kAdjective, "п 3a", {"яркого", "яркая", "яркие"}, {}},
        {"озорной", kAdjective, "п 1b",
         {"озорного", "озорному", "озорная", "озорную", "озорные"}, {}},
        {"ледяной", kAdjective, "п 1b", {"ледяного", "ледяная", "ледяные"}, {}},
        {"дверной", kAdjective, "п 1b", {"дверного", "дверная", "дверные"}, {}},
        {"тощий", kAdjective, "п 4a", {"тощего", "тощая", "тощие"}, {"тощого"}},
        {"дремучий", kAdjective, "п 4a", {"дремучего", "дремучая", "дремучие"}, {}},
        {"жгучий", kAdjective, "п 4a", {"жгучего", "жгучая", "жгучие"}, {}},

        // --- Regular verbs ---
        {"считать", kVerb, "гл 1", {"считаю", "считает", "считают", "считал",
                                    "считала"}, {}},
        {"болтать", kVerb, "гл 1", {"болтаю", "болтает", "болтал"}, {}},
        {"плавать", kVerb, "гл 1", {"плаваю", "плавает", "плавают", "плавал"}, {}},
        {"копать", kVerb, "гл 1", {"копаю", "копает", "копал"}, {}},
        {"толстеть", kVerb, "гл 1", {"толстею", "толстеет", "толстел"}, {"толщу"}},
        {"мешать", kVerb, "гл 1", {"мешаю", "мешает", "мешал"}, {"мешу"}},
        {"вешать", kVerb, "гл 1", {"вешаю", "вешает", "вешал"}, {"вешу"}},
        {"рисковать", kVerb, "гл 2", {"рискую", "рискует", "рисковал"},
         {"рисковаю"}},
        {"жертвовать", kVerb, "гл 2", {"жертвую", "жертвует", "жертвовал"},
         {"жертвоваю"}},
        {"цитировать", kVerb, "гл 2", {"цитирую", "цитирует", "цитировал"},
         {"цитироваю"}},
        {"мигнуть", kVerb, "гл 3", {"мигну", "мигнет", "мигнул"}, {}},
        {"нырнуть", kVerb, "гл 3", {"нырну", "нырнет", "нырнул"}, {}},
        {"пилить", kVerb, "гл 4", {"пилю", "пилит", "пилят", "пилил"}, {}},
        {"сверлить", kVerb, "гл 4", {"сверлю", "сверлит", "сверлил"}, {}},
        {"точить", kVerb, "гл 4", {"точу", "точит", "точат", "точил"}, {"точю"}},
        {"чинить", kVerb, "гл 4", {"чиню", "чинит", "чинил"}, {}},
        {"ценить", kVerb, "гл 4", {"ценю", "ценит", "ценил"}, {}},
        {"клеить", kVerb, "гл 4", {"клею", "клеит", "клеил"}, {}},

        // --- Second-conjugation verbs in -ать/-еть outside the rule
        //     backend's closed class-5 list ---
        {"дрожать", kVerb, "гл 5", {"дрожу", "дрожит", "дрожат", "дрожал"},
         {"дрожаю"}},
        {"жужжать", kVerb, "гл 5", {"жужжу", "жужжит", "жужжат", "жужжал"},
         {"жужжаю"}},
        {"сипеть", kVerb, "гл 5", {"сиплю", "сипит", "сипел"}, {"сипею"}},
        {"хрустеть", kVerb, "гл 5", {"хрущу", "хрустит", "хрустел"}, {"хрустею"}},
    };
    return words;
}

TScore evaluate(TAnalyzer analyzer, std::vector<TWordResult>* details) {
    TScore score;
    for (const TGoldWord& gold : goldWords()) {
        const TAnalysis analysis = analyzer(gold.word);
        TWordResult result;
        result.gold = &gold;
        result.predictedIndex = analysis.zaliznyakIndex;
        result.posCorrect = analysis.partOfSpeech == gold.partOfSpeech;
        result.classCorrect = analysis.zaliznyakIndex == gold.zaliznyakIndex;
        for (const char* form : gold.requiredForms) {
            if (std::find(analysis.forms.begin(), analysis.forms.end(), form) ==
                analysis.forms.end()) {
                result.missingForms.push_back(form);
            }
        }
        for (const char* form : gold.forbiddenForms) {
            if (std::find(analysis.forms.begin(), analysis.forms.end(), form) !=
                analysis.forms.end()) {
                result.forbiddenHits.push_back(form);
            }
        }
        result.paradigmCorrect =
            result.missingForms.empty() && result.forbiddenHits.empty();
        ++score.total;
        score.posCorrect += result.posCorrect ? 1 : 0;
        score.classCorrect += result.classCorrect ? 1 : 0;
        score.paradigmCorrect += result.paradigmCorrect ? 1 : 0;
        if (details != nullptr) {
            details->push_back(std::move(result));
        }
    }
    return score;
}

}  // namespace evaluation
}  // namespace russianMorphology
